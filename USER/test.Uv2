### uVision2 Project, (C) Keil Software
### Do not modify !

Target (Target 1), 0x0004 // Tools: 'ARM-ADS'

Group (Source Group 1)
Group (USER)
Group (SYSTEM)
Group (HARDWARE)
Group (USMART)
Group (MALLOC)
Group (FATFS)
Group (TEXT)
Group (PICTURE)
Group (CONFIG)
Group (LCDDriver)
Group (CORE)
Group (CONTROLS)

File 1,2,<.\startup_stm32f10x_hd.s><startup_stm32f10x_hd.s>
File 1,1,<..\GUI_X_Touch.c><GUI_X_Touch.c>
File 2,1,<.\test.c><test.c>
File 3,1,<..\SYSTEM\delay\delay.c><delay.c>
File 3,1,<..\SYSTEM\sys\sys.c><sys.c>
File 3,1,<..\SYSTEM\usart\usart.c><usart.c>
File 4,1,<..\HARDWARE\LED\led.c><led.c>
File 4,1,<..\HARDWARE\BEEP\beep.c><beep.c>
File 4,1,<..\HARDWARE\KEY\key.c><key.c>
File 4,1,<..\HARDWARE\EXTI\exti.c><exti.c>
File 4,1,<..\HARDWARE\WDG\wdg.c><wdg.c>
File 4,1,<..\HARDWARE\TIMER\timer.c><timer.c>
File 4,1,<..\HARDWARE\LCD\blcd.c><blcd.c>
File 4,1,<..\HARDWARE\RTC\rtc.c><rtc.c>
File 4,1,<..\HARDWARE\24CXX\myiic.c><myiic.c>
File 4,1,<..\HARDWARE\24CXX\24cxx.c><24cxx.c>
File 4,1,<..\HARDWARE\SPI\spi.c><spi.c>
File 4,1,<..\HARDWARE\SD\MMC_SD.C><MMC_SD.C>
File 4,1,<..\HARDWARE\FLASH\flash.c><flash.c>
File 4,1,<..\HARDWARE\TOUCH\touch.c><touch.c>
File 4,1,<..\HARDWARE\SRAM\sram.c><sram.c>
File 4,1,<..\HARDWARE\CTOUCH\ctiic.c><ctiic.c>
File 4,1,<..\HARDWARE\CTOUCH\gt811.c><gt811.c>
File 5,1,<..\USMART\usmart.c><usmart.c>
File 5,1,<..\USMART\usmart_config.c><usmart_config.c>
File 5,1,<..\USMART\usmart_str.c><usmart_str.c>
File 6,1,<..\MALLOC\malloc.c><malloc.c>
File 7,1,<..\FATFS\src\ff.c><ff.c>
File 7,1,<..\FATFS\src\diskio.c><diskio.c>
File 7,1,<..\FATFS\exfuns\exfuns.c><exfuns.c>
File 7,1,<..\FATFS\exfuns\fattester.c><fattester.c>
File 7,1,<..\FATFS\exfuns\mycc936.c><mycc936.c>
File 8,1,<..\TEXT\fontupd.c><fontupd.c>
File 8,1,<..\TEXT\text.c><text.c>
File 9,1,<..\PICTURE\bmp.c><bmp.c>
File 9,1,<..\PICTURE\gif.c><gif.c>
File 9,1,<..\PICTURE\jpeg.c><jpeg.c>
File 9,1,<..\PICTURE\piclib.c><piclib.c>
File 11,1,<..\GUI\LCDDriver\LCDLin32.c><LCDLin32.c>
File 11,1,<..\GUI\LCDDriver\LCDLin.c><LCDLin.c>
File 11,1,<..\GUI\LCDDriver\LCDMem.c><LCDMem.c>
File 11,1,<..\GUI\LCDDriver\LCDNull.c><LCDNull.c>
File 11,1,<..\GUI\LCDDriver\LCDTemplate.c><LCDTemplate.c>
File 11,1,<..\GUI\LCDDriver\LCDWin.c><LCDWin.c>
File 12,1,<..\GUI\Core\GUI2DLib.c><GUI2DLib.c>
File 12,1,<..\GUI\Core\GUI__AddSpaceHex.c><GUI__AddSpaceHex.c>
File 12,1,<..\GUI\Core\GUI__Arabic.c><GUI__Arabic.c>
File 12,1,<..\GUI\Core\GUI__CalcTextRect.c><GUI__CalcTextRect.c>
File 12,1,<..\GUI\Core\GUI__DivideRound32.c><GUI__DivideRound32.c>
File 12,1,<..\GUI\Core\GUI__DivideRound.c><GUI__DivideRound.c>
File 12,1,<..\GUI\Core\GUI__DrawBitmap16bpp.c><GUI__DrawBitmap16bpp.c>
File 12,1,<..\GUI\Core\GUI__GetCursorPos.c><GUI__GetCursorPos.c>
File 12,1,<..\GUI\Core\GUI__GetFontSizeY.c><GUI__GetFontSizeY.c>
File 12,1,<..\GUI\Core\GUI__GetNumChars.c><GUI__GetNumChars.c>
File 12,1,<..\GUI\Core\GUI__HandleEOLine.c><GUI__HandleEOLine.c>
File 12,1,<..\GUI\Core\GUI__IntersectRect.c><GUI__IntersectRect.c>
File 12,1,<..\GUI\Core\GUI__IntersectRects.c><GUI__IntersectRects.c>
File 12,1,<..\GUI\Core\GUI__memset16.c><GUI__memset16.c>
File 12,1,<..\GUI\Core\GUI__memset.c><GUI__memset.c>
File 12,1,<..\GUI\Core\GUI__Read.c><GUI__Read.c>
File 12,1,<..\GUI\Core\GUI__ReduceRect.c><GUI__ReduceRect.c>
File 12,1,<..\GUI\Core\GUI__SetText.c><GUI__SetText.c>
File 12,1,<..\GUI\Core\GUI__strcmp.c><GUI__strcmp.c>
File 12,1,<..\GUI\Core\GUI__strlen.c><GUI__strlen.c>
File 12,1,<..\GUI\Core\GUI__Wrap.c><GUI__Wrap.c>
File 12,1,<..\GUI\Core\GUI_AddBin.c><GUI_AddBin.c>
File 12,1,<..\GUI\Core\GUI_AddDec.c><GUI_AddDec.c>
File 12,1,<..\GUI\Core\GUI_AddDecMin.c><GUI_AddDecMin.c>
File 12,1,<..\GUI\Core\GUI_AddDecShift.c><GUI_AddDecShift.c>
File 12,1,<..\GUI\Core\GUI_AddHex.c><GUI_AddHex.c>
File 12,1,<..\GUI\Core\GUI_AddKeyMsgHook.c><GUI_AddKeyMsgHook.c>
File 12,1,<..\GUI\Core\GUI_ALLOC_AllocInit.c><GUI_ALLOC_AllocInit.c>
File 12,1,<..\GUI\Core\GUI_ALLOC_AllocZero.c><GUI_ALLOC_AllocZero.c>
File 12,1,<..\GUI\Core\GUI_BMP.c><GUI_BMP.c>
File 12,1,<..\GUI\Core\GUI_BMP_Serialize.c><GUI_BMP_Serialize.c>
File 12,1,<..\GUI\Core\GUI_CalcColorDist.c><GUI_CalcColorDist.c>
File 12,1,<..\GUI\Core\GUI_ClearRectEx.c><GUI_ClearRectEx.c>
File 12,1,<..\GUI\Core\GUI_Color2VisColor.c><GUI_Color2VisColor.c>
File 12,1,<..\GUI\Core\GUI_CursorArrowL.c><GUI_CursorArrowL.c>
File 12,1,<..\GUI\Core\GUI_CursorArrowLI.c><GUI_CursorArrowLI.c>
File 12,1,<..\GUI\Core\GUI_CursorArrowLPx.c><GUI_CursorArrowLPx.c>
File 12,1,<..\GUI\Core\GUI_CursorArrowM.c><GUI_CursorArrowM.c>
File 12,1,<..\GUI\Core\GUI_CursorArrowMI.c><GUI_CursorArrowMI.c>
File 12,1,<..\GUI\Core\GUI_CursorArrowMPx.c><GUI_CursorArrowMPx.c>
File 12,1,<..\GUI\Core\GUI_CursorArrowS.c><GUI_CursorArrowS.c>
File 12,1,<..\GUI\Core\GUI_CursorArrowSI.c><GUI_CursorArrowSI.c>
File 12,1,<..\GUI\Core\GUI_CursorArrowSPx.c><GUI_CursorArrowSPx.c>
File 12,1,<..\GUI\Core\GUI_CursorCrossL.c><GUI_CursorCrossL.c>
File 12,1,<..\GUI\Core\GUI_CursorCrossLI.c><GUI_CursorCrossLI.c>
File 12,1,<..\GUI\Core\GUI_CursorCrossLPx.c><GUI_CursorCrossLPx.c>
File 12,1,<..\GUI\Core\GUI_CursorCrossM.c><GUI_CursorCrossM.c>
File 12,1,<..\GUI\Core\GUI_CursorCrossMI.c><GUI_CursorCrossMI.c>
File 12,1,<..\GUI\Core\GUI_CursorCrossMPx.c><GUI_CursorCrossMPx.c>
File 12,1,<..\GUI\Core\GUI_CursorCrossS.c><GUI_CursorCrossS.c>
File 12,1,<..\GUI\Core\GUI_CursorCrossSI.c><GUI_CursorCrossSI.c>
File 12,1,<..\GUI\Core\GUI_CursorCrossSPx.c><GUI_CursorCrossSPx.c>
File 12,1,<..\GUI\Core\GUI_CursorHeaderM.c><GUI_CursorHeaderM.c>
File 12,1,<..\GUI\Core\GUI_CursorHeaderMI.c><GUI_CursorHeaderMI.c>
File 12,1,<..\GUI\Core\GUI_CursorHeaderMPx.c><GUI_CursorHeaderMPx.c>
File 12,1,<..\GUI\Core\GUI_CursorPal.c><GUI_CursorPal.c>
File 12,1,<..\GUI\Core\GUI_CursorPalI.c><GUI_CursorPalI.c>
File 12,1,<..\GUI\Core\GUI_DispBin.c><GUI_DispBin.c>
File 12,1,<..\GUI\Core\GUI_DispCEOL.c><GUI_DispCEOL.c>
File 12,1,<..\GUI\Core\GUI_DispChar.c><GUI_DispChar.c>
File 12,1,<..\GUI\Core\GUI_DispChars.c><GUI_DispChars.c>
File 12,1,<..\GUI\Core\GUI_DispHex.c><GUI_DispHex.c>
File 12,1,<..\GUI\Core\GUI_DispString.c><GUI_DispString.c>
File 12,1,<..\GUI\Core\GUI_DispStringAt.c><GUI_DispStringAt.c>
File 12,1,<..\GUI\Core\GUI_DispStringAtCEOL.c><GUI_DispStringAtCEOL.c>
File 12,1,<..\GUI\Core\GUI_DispStringHCenter.c><GUI_DispStringHCenter.c>
File 12,1,<..\GUI\Core\GUI_DispStringInRect.c><GUI_DispStringInRect.c>
File 12,1,<..\GUI\Core\GUI_DispStringInRectEx.c><GUI_DispStringInRectEx.c>
File 12,1,<..\GUI\Core\GUI_DispStringInRectWrap.c><GUI_DispStringInRectWrap.c>
File 12,1,<..\GUI\Core\GUI_DispStringLen.c><GUI_DispStringLen.c>
File 12,1,<..\GUI\Core\GUI_DrawBitmap.c><GUI_DrawBitmap.c>
File 12,1,<..\GUI\Core\GUI_DrawBitmap_555.c><GUI_DrawBitmap_555.c>
File 12,1,<..\GUI\Core\GUI_DrawBitmap_565.c><GUI_DrawBitmap_565.c>
File 12,1,<..\GUI\Core\GUI_DrawBitmap_888.c><GUI_DrawBitmap_888.c>
File 12,1,<..\GUI\Core\GUI_DrawBitmapEx.c><GUI_DrawBitmapEx.c>
File 12,1,<..\GUI\Core\GUI_DrawBitmapExp.c><GUI_DrawBitmapExp.c>
File 12,1,<..\GUI\Core\GUI_DrawBitmapMag.c><GUI_DrawBitmapMag.c>
File 12,1,<..\GUI\Core\GUI_DrawFocusRect.c><GUI_DrawFocusRect.c>
File 12,1,<..\GUI\Core\GUI_DrawGraph.c><GUI_DrawGraph.c>
File 12,1,<..\GUI\Core\GUI_DrawGraphEx.c><GUI_DrawGraphEx.c>
File 12,1,<..\GUI\Core\GUI_DrawHLine.c><GUI_DrawHLine.c>
File 12,1,<..\GUI\Core\GUI_DrawLine.c><GUI_DrawLine.c>
File 12,1,<..\GUI\Core\GUI_DrawPie.c><GUI_DrawPie.c>
File 12,1,<..\GUI\Core\GUI_DrawPixel.c><GUI_DrawPixel.c>
File 12,1,<..\GUI\Core\GUI_DrawPoint.c><GUI_DrawPoint.c>
File 12,1,<..\GUI\Core\GUI_DrawPolygon.c><GUI_DrawPolygon.c>
File 12,1,<..\GUI\Core\GUI_DrawPolyline.c><GUI_DrawPolyline.c>
File 12,1,<..\GUI\Core\GUI_DrawRectEx.c><GUI_DrawRectEx.c>
File 12,1,<..\GUI\Core\GUI_DrawVLine.c><GUI_DrawVLine.c>
File 12,1,<..\GUI\Core\GUI_ErrorOut.c><GUI_ErrorOut.c>
File 12,1,<..\GUI\Core\GUI_Exec.c><GUI_Exec.c>
File 12,1,<..\GUI\Core\GUI_FillPolygon.c><GUI_FillPolygon.c>
File 12,1,<..\GUI\Core\GUI_FillRect.c><GUI_FillRect.c>
File 12,1,<..\GUI\Core\GUI_FillRectEx.c><GUI_FillRectEx.c>
File 12,1,<..\GUI\Core\GUI_GetBitmapPixelColor.c><GUI_GetBitmapPixelColor.c>
File 12,1,<..\GUI\Core\GUI_GetBitmapPixelIndex.c><GUI_GetBitmapPixelIndex.c>
File 12,1,<..\GUI\Core\GUI_GetClientRect.c><GUI_GetClientRect.c>
File 12,1,<..\GUI\Core\GUI_GetColor.c><GUI_GetColor.c>
File 12,1,<..\GUI\Core\GUI_GetDispPos.c><GUI_GetDispPos.c>
File 12,1,<..\GUI\Core\GUI_GetDrawMode.c><GUI_GetDrawMode.c>
File 12,1,<..\GUI\Core\GUI_GetFont.c><GUI_GetFont.c>
File 12,1,<..\GUI\Core\GUI_GetFontInfo.c><GUI_GetFontInfo.c>
File 12,1,<..\GUI\Core\GUI_GetFontSizeY.c><GUI_GetFontSizeY.c>
File 12,1,<..\GUI\Core\GUI_GetLineStyle.c><GUI_GetLineStyle.c>
File 12,1,<..\GUI\Core\GUI_GetOrg.c><GUI_GetOrg.c>
File 12,1,<..\GUI\Core\GUI_GetStringDistX.c><GUI_GetStringDistX.c>
File 12,1,<..\GUI\Core\GUI_GetTextAlign.c><GUI_GetTextAlign.c>
File 12,1,<..\GUI\Core\GUI_GetTextExtend.c><GUI_GetTextExtend.c>
File 12,1,<..\GUI\Core\GUI_GetTextMode.c><GUI_GetTextMode.c>
File 12,1,<..\GUI\Core\GUI_GetVersionString.c><GUI_GetVersionString.c>
File 12,1,<..\GUI\Core\GUI_GetYSizeOfFont.c><GUI_GetYSizeOfFont.c>
File 12,1,<..\GUI\Core\GUI_GIF.c><GUI_GIF.c>
File 12,1,<..\GUI\Core\GUI_Goto.c><GUI_Goto.c>
File 12,1,<..\GUI\Core\GUI_InitLUT.c><GUI_InitLUT.c>
File 12,1,<..\GUI\Core\GUI_InvertRect.c><GUI_InvertRect.c>
File 12,1,<..\GUI\Core\GUI_IsInFont.c><GUI_IsInFont.c>
File 12,1,<..\GUI\Core\GUI_Log.c><GUI_Log.c>
File 12,1,<..\GUI\Core\GUI_MergeRect.c><GUI_MergeRect.c>
File 12,1,<..\GUI\Core\GUI_MOUSE.c><GUI_MOUSE.c>
File 12,1,<..\GUI\Core\GUI_MOUSE_DriverPS2.c><GUI_MOUSE_DriverPS2.c>
File 12,1,<..\GUI\Core\GUI_MoveRect.c><GUI_MoveRect.c>
File 12,1,<..\GUI\Core\GUI_OnKey.c><GUI_OnKey.c>
File 12,1,<..\GUI\Core\GUI_Pen.c><GUI_Pen.c>
File 12,1,<..\GUI\Core\GUI_PID.c><GUI_PID.c>
File 12,1,<..\GUI\Core\GUI_RectsIntersect.c><GUI_RectsIntersect.c>
File 12,1,<..\GUI\Core\GUI_SaveContext.c><GUI_SaveContext.c>
File 12,1,<..\GUI\Core\GUI_ScreenSize.c><GUI_ScreenSize.c>
File 12,1,<..\GUI\Core\GUI_SelectLayer.c><GUI_SelectLayer.c>
File 12,1,<..\GUI\Core\GUI_SelectLCD.c><GUI_SelectLCD.c>
File 12,1,<..\GUI\Core\GUI_SetClipRect.c><GUI_SetClipRect.c>
File 12,1,<..\GUI\Core\GUI_SetColor.c><GUI_SetColor.c>
File 12,1,<..\GUI\Core\GUI_SetColorIndex.c><GUI_SetColorIndex.c>
File 12,1,<..\GUI\Core\GUI_SetDecChar.c><GUI_SetDecChar.c>
File 12,1,<..\GUI\Core\GUI_SetDefault.c><GUI_SetDefault.c>
File 12,1,<..\GUI\Core\GUI_SetDrawMode.c><GUI_SetDrawMode.c>
File 12,1,<..\GUI\Core\GUI_SetFont.c><GUI_SetFont.c>
File 12,1,<..\GUI\Core\GUI_SetLBorder.c><GUI_SetLBorder.c>
File 12,1,<..\GUI\Core\GUI_SetLineStyle.c><GUI_SetLineStyle.c>
File 12,1,<..\GUI\Core\GUI_SetLUTColor.c><GUI_SetLUTColor.c>
File 12,1,<..\GUI\Core\GUI_SetLUTColorEx.c><GUI_SetLUTColorEx.c>
File 12,1,<..\GUI\Core\GUI_SetLUTEntry.c><GUI_SetLUTEntry.c>
File 12,1,<..\GUI\Core\GUI_SetOrg.c><GUI_SetOrg.c>
File 12,1,<..\GUI\Core\GUI_SetPixelIndex.c><GUI_SetPixelIndex.c>
File 12,1,<..\GUI\Core\GUI_SetTextAlign.c><GUI_SetTextAlign.c>
File 12,1,<..\GUI\Core\GUI_SetTextMode.c><GUI_SetTextMode.c>
File 12,1,<..\GUI\Core\GUI_SetTextStyle.c><GUI_SetTextStyle.c>
File 12,1,<..\GUI\Core\GUI_SIF.c><GUI_SIF.c>
File 12,1,<..\GUI\Core\GUI_SIF_Prop.c><GUI_SIF_Prop.c>
File 12,1,<..\GUI\Core\GUI_TOUCH.c><GUI_TOUCH.c>
File 12,1,<..\GUI\Core\GUI_TOUCH_DriverAnalog.c><GUI_TOUCH_DriverAnalog.c>
File 12,1,<..\GUI\Core\GUI_TOUCH_StoreState.c><GUI_TOUCH_StoreState.c>
File 12,1,<..\GUI\Core\GUI_TOUCH_StoreUnstable.c><GUI_TOUCH_StoreUnstable.c>
File 12,1,<..\GUI\Core\GUI_UC.c><GUI_UC.c>
File 12,1,<..\GUI\Core\GUI_UC_ConvertUC2UTF8.c><GUI_UC_ConvertUC2UTF8.c>
File 12,1,<..\GUI\Core\GUI_UC_ConvertUTF82UC.c><GUI_UC_ConvertUTF82UC.c>
File 12,1,<..\GUI\Core\GUI_UC_DispString.c><GUI_UC_DispString.c>
File 12,1,<..\GUI\Core\GUI_UC_EncodeNone.c><GUI_UC_EncodeNone.c>
File 12,1,<..\GUI\Core\GUI_UC_EncodeUTF8.c><GUI_UC_EncodeUTF8.c>
File 12,1,<..\GUI\Core\GUI_WaitEvent.c><GUI_WaitEvent.c>
File 12,1,<..\GUI\Core\GUI_WaitKey.c><GUI_WaitKey.c>
File 12,1,<..\GUI\Core\GUI_Warn.c><GUI_Warn.c>
File 12,1,<..\GUI\Core\GUIAlloc.c><GUIAlloc.c>
File 12,1,<..\GUI\Core\GUIArc.c><GUIArc.c>
File 12,1,<..\GUI\Core\GUIChar.c><GUIChar.c>
File 12,1,<..\GUI\Core\GUICharLine.c><GUICharLine.c>
File 12,1,<..\GUI\Core\GUICharM.c><GUICharM.c>
File 12,1,<..\GUI\Core\GUICharP.c><GUICharP.c>
File 12,1,<..\GUI\Core\GUICirc.c><GUICirc.c>
File 12,1,<..\GUI\Core\GUIColor2Index.c><GUIColor2Index.c>
File 12,1,<..\GUI\Core\GUICore.c><GUICore.c>
File 12,1,<..\GUI\Core\GUICurs.c><GUICurs.c>
File 12,1,<..\GUI\Core\GUIEncJS.c><GUIEncJS.c>
File 12,1,<..\GUI\Core\GUIIndex2Color.c><GUIIndex2Color.c>
File 12,1,<..\GUI\Core\GUIPolyE.c><GUIPolyE.c>
File 12,1,<..\GUI\Core\GUIPolyM.c><GUIPolyM.c>
File 12,1,<..\GUI\Core\GUIPolyR.c><GUIPolyR.c>
File 12,1,<..\GUI\Core\GUIRealloc.c><GUIRealloc.c>
File 12,1,<..\GUI\Core\GUIStream.c><GUIStream.c>
File 12,1,<..\GUI\Core\GUITask.c><GUITask.c>
File 12,1,<..\GUI\Core\GUITime.c><GUITime.c>
File 12,1,<..\GUI\Core\GUITimer.c><GUITimer.c>
File 12,1,<..\GUI\Core\GUIUC0.c><GUIUC0.c>
File 12,1,<..\GUI\Core\GUIVal.c><GUIVal.c>
File 12,1,<..\GUI\Core\GUIValf.c><GUIValf.c>
File 12,1,<..\GUI\Core\LCD.c><LCD.c>
File 12,1,<..\GUI\Core\LCD_API.c><LCD_API.c>
File 12,1,<..\GUI\Core\LCD_DrawVLine.c><LCD_DrawVLine.c>
File 12,1,<..\GUI\Core\LCD_GetColorIndex.c><LCD_GetColorIndex.c>
File 12,1,<..\GUI\Core\LCD_GetEx.c><LCD_GetEx.c>
File 12,1,<..\GUI\Core\LCD_GetNumDisplays.c><LCD_GetNumDisplays.c>
File 12,1,<..\GUI\Core\LCD_GetPixelColor.c><LCD_GetPixelColor.c>
File 12,1,<..\GUI\Core\LCD_Index2ColorEx.c><LCD_Index2ColorEx.c>
File 12,1,<..\GUI\Core\LCD_L0_Generic.c><LCD_L0_Generic.c>
File 12,1,<..\GUI\Core\LCD_Mirror.c><LCD_Mirror.c>
File 12,1,<..\GUI\Core\LCD_MixColors256.c><LCD_MixColors256.c>
File 12,1,<..\GUI\Core\LCD_ReadRect.c><LCD_ReadRect.c>
File 12,1,<..\GUI\Core\LCD_Rotate180.c><LCD_Rotate180.c>
File 12,1,<..\GUI\Core\LCD_RotateCCW.c><LCD_RotateCCW.c>
File 12,1,<..\GUI\Core\LCD_RotateCW.c><LCD_RotateCW.c>
File 12,1,<..\GUI\Core\LCD_SelectLCD.c><LCD_SelectLCD.c>
File 12,1,<..\GUI\Core\LCD_SetAPI.c><LCD_SetAPI.c>
File 12,1,<..\GUI\Core\LCD_SetClipRectEx.c><LCD_SetClipRectEx.c>
File 12,1,<..\GUI\Core\LCD_UpdateColorIndices.c><LCD_UpdateColorIndices.c>
File 12,1,<..\GUI\Core\LCDAA.c><LCDAA.c>
File 12,1,<..\GUI\Core\LCDColor.c><LCDColor.c>
File 12,1,<..\GUI\Core\LCDGetP.c><LCDGetP.c>
File 12,1,<..\GUI\Core\LCDInfo0.c><LCDInfo0.c>
File 12,1,<..\GUI\Core\LCDInfo1.c><LCDInfo1.c>
File 12,1,<..\GUI\Core\LCDInfo.c><LCDInfo.c>
File 12,1,<..\GUI\Core\LCDL0Delta.c><LCDL0Delta.c>
File 12,1,<..\GUI\Core\LCDL0Mag.c><LCDL0Mag.c>
File 12,1,<..\GUI\Core\LCDP1.c><LCDP1.c>
File 12,1,<..\GUI\Core\LCDP565_Index2Color.c><LCDP565_Index2Color.c>
File 12,1,<..\GUI\Core\LCDP888_Index2Color.c><LCDP888_Index2Color.c>
File 12,1,<..\GUI\Core\LCDPM565_Index2Color.c><LCDPM565_Index2Color.c>
File 12,1,<..\GUI\Core\LCDPM888_Index2Color.c><LCDPM888_Index2Color.c>
File 12,1,<..\GUI\Core\LCDRLE4.c><LCDRLE4.c>
File 12,1,<..\GUI\Core\LCDRLE8.c><LCDRLE8.c>
File 12,1,<..\GUI\Core\LCDRLE16.c><LCDRLE16.c>
File 13,1,<..\GUI\Widget\BUTTON.c><BUTTON.c>
File 13,1,<..\GUI\Widget\BUTTON__SetBitmapObj.c><BUTTON__SetBitmapObj.c>
File 13,1,<..\GUI\Widget\BUTTON_Bitmap.c><BUTTON_Bitmap.c>
File 13,1,<..\GUI\Widget\BUTTON_BMP.c><BUTTON_BMP.c>
File 13,1,<..\GUI\Widget\BUTTON_Create.c><BUTTON_Create.c>
File 13,1,<..\GUI\Widget\BUTTON_CreateIndirect.c><BUTTON_CreateIndirect.c>
File 13,1,<..\GUI\Widget\BUTTON_Default.c><BUTTON_Default.c>
File 13,1,<..\GUI\Widget\BUTTON_Get.c><BUTTON_Get.c>
File 13,1,<..\GUI\Widget\BUTTON_GetBitmap.c><BUTTON_GetBitmap.c>
File 13,1,<..\GUI\Widget\BUTTON_IsPressed.c><BUTTON_IsPressed.c>
File 13,1,<..\GUI\Widget\BUTTON_SelfDraw.c><BUTTON_SelfDraw.c>
File 13,1,<..\GUI\Widget\BUTTON_SetFocusColor.c><BUTTON_SetFocusColor.c>
File 13,1,<..\GUI\Widget\BUTTON_SetTextAlign.c><BUTTON_SetTextAlign.c>
File 13,1,<..\GUI\Widget\BUTTON_StreamedBitmap.c><BUTTON_StreamedBitmap.c>
File 13,1,<..\GUI\Widget\CHECKBOX.c><CHECKBOX.c>
File 13,1,<..\GUI\Widget\CHECKBOX_Create.c><CHECKBOX_Create.c>
File 13,1,<..\GUI\Widget\CHECKBOX_CreateIndirect.c><CHECKBOX_CreateIndirect.c>
File 13,1,<..\GUI\Widget\CHECKBOX_Default.c><CHECKBOX_Default.c>
File 13,1,<..\GUI\Widget\CHECKBOX_GetState.c><CHECKBOX_GetState.c>
File 13,1,<..\GUI\Widget\CHECKBOX_GetText.c><CHECKBOX_GetText.c>
File 13,1,<..\GUI\Widget\CHECKBOX_Image.c><CHECKBOX_Image.c>
File 13,1,<..\GUI\Widget\CHECKBOX_IsChecked.c><CHECKBOX_IsChecked.c>
File 13,1,<..\GUI\Widget\CHECKBOX_SetBkColor.c><CHECKBOX_SetBkColor.c>
File 13,1,<..\GUI\Widget\CHECKBOX_SetBoxBkColor.c><CHECKBOX_SetBoxBkColor.c>
File 13,1,<..\GUI\Widget\CHECKBOX_SetDefaultImage.c><CHECKBOX_SetDefaultImage.c>
File 13,1,<..\GUI\Widget\CHECKBOX_SetFocusColor.c><CHECKBOX_SetFocusColor.c>
File 13,1,<..\GUI\Widget\CHECKBOX_SetFont.c><CHECKBOX_SetFont.c>
File 13,1,<..\GUI\Widget\CHECKBOX_SetImage.c><CHECKBOX_SetImage.c>
File 13,1,<..\GUI\Widget\CHECKBOX_SetNumStates.c><CHECKBOX_SetNumStates.c>
File 13,1,<..\GUI\Widget\CHECKBOX_SetSpacing.c><CHECKBOX_SetSpacing.c>
File 13,1,<..\GUI\Widget\CHECKBOX_SetState.c><CHECKBOX_SetState.c>
File 13,1,<..\GUI\Widget\CHECKBOX_SetText.c><CHECKBOX_SetText.c>
File 13,1,<..\GUI\Widget\CHECKBOX_SetTextAlign.c><CHECKBOX_SetTextAlign.c>
File 13,1,<..\GUI\Widget\CHECKBOX_SetTextColor.c><CHECKBOX_SetTextColor.c>
File 13,1,<..\GUI\Widget\DIALOG.c><DIALOG.c>
File 13,1,<..\GUI\Widget\DROPDOWN.c><DROPDOWN.c>
File 13,1,<..\GUI\Widget\DROPDOWN_AddString.c><DROPDOWN_AddString.c>
File 13,1,<..\GUI\Widget\DROPDOWN_Create.c><DROPDOWN_Create.c>
File 13,1,<..\GUI\Widget\DROPDOWN_CreateIndirect.c><DROPDOWN_CreateIndirect.c>
File 13,1,<..\GUI\Widget\DROPDOWN_Default.c><DROPDOWN_Default.c>
File 13,1,<..\GUI\Widget\DROPDOWN_DeleteItem.c><DROPDOWN_DeleteItem.c>
File 13,1,<..\GUI\Widget\DROPDOWN_GetNumItems.c><DROPDOWN_GetNumItems.c>
File 13,1,<..\GUI\Widget\DROPDOWN_InsertString.c><DROPDOWN_InsertString.c>
File 13,1,<..\GUI\Widget\DROPDOWN_ItemSpacing.c><DROPDOWN_ItemSpacing.c>
File 13,1,<..\GUI\Widget\DROPDOWN_SetAutoScroll.c><DROPDOWN_SetAutoScroll.c>
File 13,1,<..\GUI\Widget\DROPDOWN_SetBkColor.c><DROPDOWN_SetBkColor.c>
File 13,1,<..\GUI\Widget\DROPDOWN_SetColor.c><DROPDOWN_SetColor.c>
File 13,1,<..\GUI\Widget\DROPDOWN_SetFont.c><DROPDOWN_SetFont.c>
File 13,1,<..\GUI\Widget\DROPDOWN_SetScrollbarColor.c><DROPDOWN_SetScrollbarColor.c>
File 13,1,<..\GUI\Widget\DROPDOWN_SetScrollbarWidth.c><DROPDOWN_SetScrollbarWidth.c>
File 13,1,<..\GUI\Widget\DROPDOWN_SetTextAlign.c><DROPDOWN_SetTextAlign.c>
File 13,1,<..\GUI\Widget\DROPDOWN_SetTextColor.c><DROPDOWN_SetTextColor.c>
File 13,1,<..\GUI\Widget\DROPDOWN_SetTextHeight.c><DROPDOWN_SetTextHeight.c>
File 13,1,<..\GUI\Widget\EDIT.c><EDIT.c>
File 13,1,<..\GUI\Widget\EDIT_Create.c><EDIT_Create.c>
File 13,1,<..\GUI\Widget\EDIT_CreateIndirect.c><EDIT_CreateIndirect.c>
File 13,1,<..\GUI\Widget\EDIT_Default.c><EDIT_Default.c>
File 13,1,<..\GUI\Widget\EDIT_GetCursorPixelPos.c><EDIT_GetCursorPixelPos.c>
File 13,1,<..\GUI\Widget\EDIT_GetCursorPos.c><EDIT_GetCursorPos.c>
File 13,1,<..\GUI\Widget\EDIT_GetNumChars.c><EDIT_GetNumChars.c>
File 13,1,<..\GUI\Widget\EDIT_SetCursorAtChar.c><EDIT_SetCursorAtChar.c>
File 13,1,<..\GUI\Widget\EDIT_SetFocussable.c><EDIT_SetFocussable.c>
File 13,1,<..\GUI\Widget\EDIT_SetInsertMode.c><EDIT_SetInsertMode.c>
File 13,1,<..\GUI\Widget\EDIT_SetpfAddKeyEx.c><EDIT_SetpfAddKeyEx.c>
File 13,1,<..\GUI\Widget\EDIT_SetpfUpdateBuffer.c><EDIT_SetpfUpdateBuffer.c>
File 13,1,<..\GUI\Widget\EDIT_SetSel.c><EDIT_SetSel.c>
File 13,1,<..\GUI\Widget\EDIT_SetTextMode.c><EDIT_SetTextMode.c>
File 13,1,<..\GUI\Widget\EDITBin.c><EDITBin.c>
File 13,1,<..\GUI\Widget\EDITDec.c><EDITDec.c>
File 13,1,<..\GUI\Widget\EDITFloat.c><EDITFloat.c>
File 13,1,<..\GUI\Widget\EDITHex.c><EDITHex.c>
File 13,1,<..\GUI\Widget\EDITUlong.c><EDITUlong.c>
File 13,1,<..\GUI\Widget\FRAMEWIN.c><FRAMEWIN.c>
File 13,1,<..\GUI\Widget\FRAMEWIN__UpdateButtons.c><FRAMEWIN__UpdateButtons.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_AddMenu.c><FRAMEWIN_AddMenu.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_Button.c><FRAMEWIN_Button.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_ButtonClose.c><FRAMEWIN_ButtonClose.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_ButtonMax.c><FRAMEWIN_ButtonMax.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_ButtonMin.c><FRAMEWIN_ButtonMin.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_Create.c><FRAMEWIN_Create.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_CreateIndirect.c><FRAMEWIN_CreateIndirect.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_Default.c><FRAMEWIN_Default.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_Get.c><FRAMEWIN_Get.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_IsMinMax.c><FRAMEWIN_IsMinMax.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_MinMaxRest.c><FRAMEWIN_MinMaxRest.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_SetBorderSize.c><FRAMEWIN_SetBorderSize.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_SetColors.c><FRAMEWIN_SetColors.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_SetFont.c><FRAMEWIN_SetFont.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_SetResizeable.c><FRAMEWIN_SetResizeable.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_SetTitleHeight.c><FRAMEWIN_SetTitleHeight.c>
File 13,1,<..\GUI\Widget\FRAMEWIN_SetTitleVis.c><FRAMEWIN_SetTitleVis.c>
File 13,1,<..\GUI\Widget\GRAPH.c><GRAPH.c>
File 13,1,<..\GUI\Widget\GRAPH_CreateIndirect.c><GRAPH_CreateIndirect.c>
File 13,1,<..\GUI\Widget\GRAPH_DATA_XY.c><GRAPH_DATA_XY.c>
File 13,1,<..\GUI\Widget\GRAPH_DATA_YT.c><GRAPH_DATA_YT.c>
File 13,1,<..\GUI\Widget\GRAPH_SCALE.c><GRAPH_SCALE.c>
File 13,1,<..\GUI\Widget\GUI_ARRAY.c><GUI_ARRAY.c>
File 13,1,<..\GUI\Widget\GUI_ARRAY_DeleteItem.c><GUI_ARRAY_DeleteItem.c>
File 13,1,<..\GUI\Widget\GUI_ARRAY_InsertItem.c><GUI_ARRAY_InsertItem.c>
File 13,1,<..\GUI\Widget\GUI_ARRAY_ResizeItem.c><GUI_ARRAY_ResizeItem.c>
File 13,1,<..\GUI\Widget\GUI_DRAW.c><GUI_DRAW.c>
File 13,1,<..\GUI\Widget\GUI_DRAW_BITMAP.c><GUI_DRAW_BITMAP.c>
File 13,1,<..\GUI\Widget\GUI_DRAW_BMP.c><GUI_DRAW_BMP.c>
File 13,1,<..\GUI\Widget\GUI_DRAW_Self.c><GUI_DRAW_Self.c>
File 13,1,<..\GUI\Widget\GUI_DRAW_STREAMED.c><GUI_DRAW_STREAMED.c>
File 13,1,<..\GUI\Widget\GUI_EditBin.c><GUI_EditBin.c>
File 13,1,<..\GUI\Widget\GUI_EditDec.c><GUI_EditDec.c>
File 13,1,<..\GUI\Widget\GUI_EditFloat.c><GUI_EditFloat.c>
File 13,1,<..\GUI\Widget\GUI_EditHex.c><GUI_EditHex.c>
File 13,1,<..\GUI\Widget\GUI_EditString.c><GUI_EditString.c>
File 13,1,<..\GUI\Widget\GUI_HOOK.c><GUI_HOOK.c>
File 13,1,<..\GUI\Widget\HEADER.c><HEADER.c>
File 13,1,<..\GUI\Widget\HEADER__SetDrawObj.c><HEADER__SetDrawObj.c>
File 13,1,<..\GUI\Widget\HEADER_Bitmap.c><HEADER_Bitmap.c>
File 13,1,<..\GUI\Widget\HEADER_BMP.c><HEADER_BMP.c>
File 13,1,<..\GUI\Widget\HEADER_Create.c><HEADER_Create.c>
File 13,1,<..\GUI\Widget\HEADER_CreateIndirect.c><HEADER_CreateIndirect.c>
File 13,1,<..\GUI\Widget\HEADER_GetSel.c><HEADER_GetSel.c>
File 13,1,<..\GUI\Widget\HEADER_SetDragLimit.c><HEADER_SetDragLimit.c>
File 13,1,<..\GUI\Widget\HEADER_StreamedBitmap.c><HEADER_StreamedBitmap.c>
File 13,1,<..\GUI\Widget\LISTBOX.c><LISTBOX.c>
File 13,1,<..\GUI\Widget\LISTBOX_Create.c><LISTBOX_Create.c>
File 13,1,<..\GUI\Widget\LISTBOX_CreateIndirect.c><LISTBOX_CreateIndirect.c>
File 13,1,<..\GUI\Widget\LISTBOX_Default.c><LISTBOX_Default.c>
File 13,1,<..\GUI\Widget\LISTBOX_DeleteItem.c><LISTBOX_DeleteItem.c>
File 13,1,<..\GUI\Widget\LISTBOX_Font.c><LISTBOX_Font.c>
File 13,1,<..\GUI\Widget\LISTBOX_GetItemText.c><LISTBOX_GetItemText.c>
File 13,1,<..\GUI\Widget\LISTBOX_GetNumItems.c><LISTBOX_GetNumItems.c>
File 13,1,<..\GUI\Widget\LISTBOX_GetTextAlign.c><LISTBOX_GetTextAlign.c>
File 13,1,<..\GUI\Widget\LISTBOX_InsertString.c><LISTBOX_InsertString.c>
File 13,1,<..\GUI\Widget\LISTBOX_ItemDisabled.c><LISTBOX_ItemDisabled.c>
File 13,1,<..\GUI\Widget\LISTBOX_ItemSpacing.c><LISTBOX_ItemSpacing.c>
File 13,1,<..\GUI\Widget\LISTBOX_MultiSel.c><LISTBOX_MultiSel.c>
File 13,1,<..\GUI\Widget\LISTBOX_ScrollStep.c><LISTBOX_ScrollStep.c>
File 13,1,<..\GUI\Widget\LISTBOX_SetAutoScroll.c><LISTBOX_SetAutoScroll.c>
File 13,1,<..\GUI\Widget\LISTBOX_SetBkColor.c><LISTBOX_SetBkColor.c>
File 13,1,<..\GUI\Widget\LISTBOX_SetOwner.c><LISTBOX_SetOwner.c>
File 13,1,<..\GUI\Widget\LISTBOX_SetOwnerDraw.c><LISTBOX_SetOwnerDraw.c>
File 13,1,<..\GUI\Widget\LISTBOX_SetScrollbarColor.c><LISTBOX_SetScrollbarColor.c>
File 13,1,<..\GUI\Widget\LISTBOX_SetScrollbarWidth.c><LISTBOX_SetScrollbarWidth.c>
File 13,1,<..\GUI\Widget\LISTBOX_SetString.c><LISTBOX_SetString.c>
File 13,1,<..\GUI\Widget\LISTBOX_SetTextAlign.c><LISTBOX_SetTextAlign.c>
File 13,1,<..\GUI\Widget\LISTBOX_SetTextColor.c><LISTBOX_SetTextColor.c>
File 13,1,<..\GUI\Widget\LISTVIEW.c><LISTVIEW.c>
File 13,1,<..\GUI\Widget\LISTVIEW_Create.c><LISTVIEW_Create.c>
File 13,1,<..\GUI\Widget\LISTVIEW_CreateIndirect.c><LISTVIEW_CreateIndirect.c>
File 13,1,<..\GUI\Widget\LISTVIEW_Default.c><LISTVIEW_Default.c>
File 13,1,<..\GUI\Widget\LISTVIEW_DeleteAllRows.c><LISTVIEW_DeleteAllRows.c>
File 13,1,<..\GUI\Widget\LISTVIEW_DeleteColumn.c><LISTVIEW_DeleteColumn.c>
File 13,1,<..\GUI\Widget\LISTVIEW_DeleteRow.c><LISTVIEW_DeleteRow.c>
File 13,1,<..\GUI\Widget\LISTVIEW_DisableRow.c><LISTVIEW_DisableRow.c>
File 13,1,<..\GUI\Widget\LISTVIEW_GetBkColor.c><LISTVIEW_GetBkColor.c>
File 13,1,<..\GUI\Widget\LISTVIEW_GetFont.c><LISTVIEW_GetFont.c>
File 13,1,<..\GUI\Widget\LISTVIEW_GetHeader.c><LISTVIEW_GetHeader.c>
File 13,1,<..\GUI\Widget\LISTVIEW_GetItemText.c><LISTVIEW_GetItemText.c>
File 13,1,<..\GUI\Widget\LISTVIEW_GetNumColumns.c><LISTVIEW_GetNumColumns.c>
File 13,1,<..\GUI\Widget\LISTVIEW_GetNumRows.c><LISTVIEW_GetNumRows.c>
File 13,1,<..\GUI\Widget\LISTVIEW_GetSel.c><LISTVIEW_GetSel.c>
File 13,1,<..\GUI\Widget\LISTVIEW_GetTextColor.c><LISTVIEW_GetTextColor.c>
File 13,1,<..\GUI\Widget\LISTVIEW_InsertRow.c><LISTVIEW_InsertRow.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetAutoScroll.c><LISTVIEW_SetAutoScroll.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetBkColor.c><LISTVIEW_SetBkColor.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetColumnWidth.c><LISTVIEW_SetColumnWidth.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetFont.c><LISTVIEW_SetFont.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetGridVis.c><LISTVIEW_SetGridVis.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetItemColor.c><LISTVIEW_SetItemColor.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetItemText.c><LISTVIEW_SetItemText.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetLBorder.c><LISTVIEW_SetLBorder.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetRBorder.c><LISTVIEW_SetRBorder.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetRowHeight.c><LISTVIEW_SetRowHeight.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetSel.c><LISTVIEW_SetSel.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetSort.c><LISTVIEW_SetSort.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetTextAlign.c><LISTVIEW_SetTextAlign.c>
File 13,1,<..\GUI\Widget\LISTVIEW_SetTextColor.c><LISTVIEW_SetTextColor.c>
File 13,1,<..\GUI\Widget\LISTVIEW_UserData.c><LISTVIEW_UserData.c>
File 13,1,<..\GUI\Widget\MENU.c><MENU.c>
File 13,1,<..\GUI\Widget\MENU__FindItem.c><MENU__FindItem.c>
File 13,1,<..\GUI\Widget\MENU_Attach.c><MENU_Attach.c>
File 13,1,<..\GUI\Widget\MENU_CreateIndirect.c><MENU_CreateIndirect.c>
File 13,1,<..\GUI\Widget\MENU_Default.c><MENU_Default.c>
File 13,1,<..\GUI\Widget\MENU_DeleteItem.c><MENU_DeleteItem.c>
File 13,1,<..\GUI\Widget\MENU_DisableItem.c><MENU_DisableItem.c>
File 13,1,<..\GUI\Widget\MENU_EnableItem.c><MENU_EnableItem.c>
File 13,1,<..\GUI\Widget\MENU_GetItem.c><MENU_GetItem.c>
File 13,1,<..\GUI\Widget\MENU_GetItemText.c><MENU_GetItemText.c>
File 13,1,<..\GUI\Widget\MENU_GetNumItems.c><MENU_GetNumItems.c>
File 13,1,<..\GUI\Widget\MENU_InsertItem.c><MENU_InsertItem.c>
File 13,1,<..\GUI\Widget\MENU_Popup.c><MENU_Popup.c>
File 13,1,<..\GUI\Widget\MENU_SetBkColor.c><MENU_SetBkColor.c>
File 13,1,<..\GUI\Widget\MENU_SetBorderSize.c><MENU_SetBorderSize.c>
File 13,1,<..\GUI\Widget\MENU_SetFont.c><MENU_SetFont.c>
File 13,1,<..\GUI\Widget\MENU_SetItem.c><MENU_SetItem.c>
File 13,1,<..\GUI\Widget\MENU_SetTextColor.c><MENU_SetTextColor.c>
File 13,1,<..\GUI\Widget\MESSAGEBOX.c><MESSAGEBOX.c>
File 13,1,<..\GUI\Widget\MULTIEDIT.c><MULTIEDIT.c>
File 13,1,<..\GUI\Widget\MULTIEDIT_Create.c><MULTIEDIT_Create.c>
File 13,1,<..\GUI\Widget\MULTIEDIT_CreateIndirect.c><MULTIEDIT_CreateIndirect.c>
File 13,1,<..\GUI\Widget\MULTIPAGE.c><MULTIPAGE.c>
File 13,1,<..\GUI\Widget\MULTIPAGE_Create.c><MULTIPAGE_Create.c>
File 13,1,<..\GUI\Widget\MULTIPAGE_CreateIndirect.c><MULTIPAGE_CreateIndirect.c>
File 13,1,<..\GUI\Widget\MULTIPAGE_Default.c><MULTIPAGE_Default.c>
File 13,1,<..\GUI\Widget\PROGBAR.c><PROGBAR.c>
File 13,1,<..\GUI\Widget\PROGBAR_Create.c><PROGBAR_Create.c>
File 13,1,<..\GUI\Widget\PROGBAR_CreateIndirect.c><PROGBAR_CreateIndirect.c>
File 13,1,<..\GUI\Widget\PROGBAR_SetBarColor.c><PROGBAR_SetBarColor.c>
File 13,1,<..\GUI\Widget\PROGBAR_SetFont.c><PROGBAR_SetFont.c>
File 13,1,<..\GUI\Widget\PROGBAR_SetMinMax.c><PROGBAR_SetMinMax.c>
File 13,1,<..\GUI\Widget\PROGBAR_SetText.c><PROGBAR_SetText.c>
File 13,1,<..\GUI\Widget\PROGBAR_SetTextAlign.c><PROGBAR_SetTextAlign.c>
File 13,1,<..\GUI\Widget\PROGBAR_SetTextColor.c><PROGBAR_SetTextColor.c>
File 13,1,<..\GUI\Widget\PROGBAR_SetTextPos.c><PROGBAR_SetTextPos.c>
File 13,1,<..\GUI\Widget\RADIO.c><RADIO.c>
File 13,1,<..\GUI\Widget\RADIO_Create.c><RADIO_Create.c>
File 13,1,<..\GUI\Widget\RADIO_CreateIndirect.c><RADIO_CreateIndirect.c>
File 13,1,<..\GUI\Widget\RADIO_Default.c><RADIO_Default.c>
File 13,1,<..\GUI\Widget\RADIO_GetText.c><RADIO_GetText.c>
File 13,1,<..\GUI\Widget\RADIO_Image.c><RADIO_Image.c>
File 13,1,<..\GUI\Widget\RADIO_SetBkColor.c><RADIO_SetBkColor.c>
File 13,1,<..\GUI\Widget\RADIO_SetDefaultImage.c><RADIO_SetDefaultImage.c>
File 13,1,<..\GUI\Widget\RADIO_SetFocusColor.c><RADIO_SetFocusColor.c>
File 13,1,<..\GUI\Widget\RADIO_SetFont.c><RADIO_SetFont.c>
File 13,1,<..\GUI\Widget\RADIO_SetGroupId.c><RADIO_SetGroupId.c>
File 13,1,<..\GUI\Widget\RADIO_SetImage.c><RADIO_SetImage.c>
File 13,1,<..\GUI\Widget\RADIO_SetText.c><RADIO_SetText.c>
File 13,1,<..\GUI\Widget\RADIO_SetTextColor.c><RADIO_SetTextColor.c>
File 13,1,<..\GUI\Widget\SCROLLBAR.c><SCROLLBAR.c>
File 13,1,<..\GUI\Widget\SCROLLBAR_Create.c><SCROLLBAR_Create.c>
File 13,1,<..\GUI\Widget\SCROLLBAR_CreateIndirect.c><SCROLLBAR_CreateIndirect.c>
File 13,1,<..\GUI\Widget\SCROLLBAR_Defaults.c><SCROLLBAR_Defaults.c>
File 13,1,<..\GUI\Widget\SCROLLBAR_GetValue.c><SCROLLBAR_GetValue.c>
File 13,1,<..\GUI\Widget\SCROLLBAR_SetColor.c><SCROLLBAR_SetColor.c>
File 13,1,<..\GUI\Widget\SCROLLBAR_SetWidth.c><SCROLLBAR_SetWidth.c>
File 13,1,<..\GUI\Widget\SLIDER.c><SLIDER.c>
File 13,1,<..\GUI\Widget\SLIDER_Create.c><SLIDER_Create.c>
File 13,1,<..\GUI\Widget\SLIDER_CreateIndirect.c><SLIDER_CreateIndirect.c>
File 13,1,<..\GUI\Widget\SLIDER_Default.c><SLIDER_Default.c>
File 13,1,<..\GUI\Widget\SLIDER_SetFocusColor.c><SLIDER_SetFocusColor.c>
File 13,1,<..\GUI\Widget\TEXT_Create.c><TEXT_Create.c>
File 13,1,<..\GUI\Widget\TEXT_CreateIndirect.c><TEXT_CreateIndirect.c>
File 13,1,<..\GUI\Widget\TEXT_Default.c><TEXT_Default.c>
File 13,1,<..\GUI\Widget\TEXT_SetBkColor.c><TEXT_SetBkColor.c>
File 13,1,<..\GUI\Widget\TEXT_SetFont.c><TEXT_SetFont.c>
File 13,1,<..\GUI\Widget\TEXT_SetText.c><TEXT_SetText.c>
File 13,1,<..\GUI\Widget\TEXT_SetTextAlign.c><TEXT_SetTextAlign.c>
File 13,1,<..\GUI\Widget\TEXT_SetTextColor.c><TEXT_SetTextColor.c>
File 13,1,<..\GUI\Widget\TEXT_SetWrapMode.c><TEXT_SetWrapMode.c>
File 13,1,<..\GUI\Widget\WIDGET.c><WIDGET.c>
File 13,1,<..\GUI\Widget\WIDGET_Effect_3D1L.c><WIDGET_Effect_3D1L.c>
File 13,1,<..\GUI\Widget\WIDGET_Effect_3D2L.c><WIDGET_Effect_3D2L.c>
File 13,1,<..\GUI\Widget\WIDGET_Effect_3D.c><WIDGET_Effect_3D.c>
File 13,1,<..\GUI\Widget\WIDGET_Effect_None.c><WIDGET_Effect_None.c>
File 13,1,<..\GUI\Widget\WIDGET_Effect_Simple.c><WIDGET_Effect_Simple.c>
File 13,1,<..\GUI\Widget\WIDGET_FillStringInRect.c><WIDGET_FillStringInRect.c>
File 13,1,<..\GUI\Widget\WIDGET_SetEffect.c><WIDGET_SetEffect.c>
File 13,1,<..\GUI\Widget\WIDGET_SetWidth.c><WIDGET_SetWidth.c>
File 13,1,<..\GUI\Widget\WINDOW.c><WINDOW.c>
File 13,1,<..\GUI\Widget\WINDOW_Default.c><WINDOW_Default.c>


Options 1,0,0  // Target 'Target 1'
 Device (STM32F103ZE)
 Vendor (STMicroelectronics)
 Cpu (IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3"))
 FlashUt ()
 StupF ("STARTUP\ST\STM32F10x.s" ("STM32 Startup Code"))
 FlashDR (UL2CM3(-O14 -S0 -C0 -N00("ARM Cortex-M3") -D00(1BA00477) -L00(4) -FO7 -FD20000000 -FC800 -FN1 -FF0STM32F10x_512 -FS08000000 -FL080000))
 DevID (4216)
 Rgf (stm32f10x_lib.h)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (ST\STM32F10x\)
 OrgReg (ST\STM32F10x\)
 TgStat=16
 OutDir (..\OBJ\)
 OutName (test)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (..\OBJ\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 GLFLAGS=1790
 ADSFLGA { 243,31,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ACPUTYP ("Cortex-M3")
 RVDEV ()
 ADSTFLGA { 0,12,0,2,99,0,0,66,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMADSOCM { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMADSIRAM { 0,0,0,0,32,0,0,1,0 }
 OCMADSIROM { 1,0,0,0,8,0,0,8,0 }
 OCMADSXRAM { 0,0,0,0,0,0,0,0,0 }
 OCR_RVCT { 1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,8,0,0,8,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,32,0,0,1,0,0,0,0,0,0,0,0,0,0 }
 RV_STAVEC ()
 ADSCCFLG { 5,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSCMISC ()
 ADSCDEFN (STM32F10X_HD,USE_STDPERIPH_DRIVER)
 ADSCUDEF ()
 ADSCINCD (..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USMART;..\MALLOC;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\PICTURE;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\SD;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\RDA5820;..\HARDWARE\SRAM;..\HARDWARE\CTOUCH;..\;..\GUI\CORE;..\GUI\LCDDriver;..\GUI\Widget;..\CONFIG;..\GUI\WM)
 ADSASFLG { 1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSAMISC ()
 ADSADEFN ()
 ADSAUDEF ()
 ADSAINCD ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 ADSLDFG { 17,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSLDTA (0x08000000)
 ADSLDDA (0x20000000)
 ADSLDSC ()
 ADSLDIB ()
 ADSLDIC ()
 ADSLDMC ()
 ADSLDIF ()
 ADSLDDW ()
  OPTDL (SARMCM3.DLL)()(DARMSTM.DLL)(-pSTM32F103ZE)(SARMCM3.DLL)()(TARMSTM.DLL)(-pSTM32F103ZE)
  OPTDBG 49150,7,()()()()()()()()()() (Segger\JL2CM3.dll)()()()
 FLASH1 { 9,0,0,0,1,0,0,0,5,16,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (Segger\JL2CM3.dll)
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

